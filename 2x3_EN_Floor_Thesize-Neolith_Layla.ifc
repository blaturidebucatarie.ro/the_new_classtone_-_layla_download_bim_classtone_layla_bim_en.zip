Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2020-10-22T14:41:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 22 14:41:03 2020 * Host: DESKTOP-JN0GAD3 * Database: C:\Users\Tatiana\AppData\Local\Temp\{9CE4DDEB-E9CC-4FF6-B638-8E76F31A9876}\ifc * Database version: 5507 * Database creation date: Thu Oct 22 14:41:03 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 22 14:41:03 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 22 14:41:03 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished, Floor:Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished:202342
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1500x6mm+ Pulido 6 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Polished; TotalThickness: 6 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1500x6mm+ Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - IsExternal: yes; EsExterior: yes; CEMark: yes; IsExtendedWarranty: yes; Model: Layla_low 6mm+ Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Polished; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1500 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1500x6mm+ Polished; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.15 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Level: Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 25 m2; Elevation at Bottom: -6 mm; Perimeter: 20000 mm; Thickness: 6 mm; Volume: 0.15 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Roughness: 1; Absorptance: 0.1; Heat Transfer Coefficient (U): 216.667; Thermal mass: 120384; Thermal Resistance (R): 0.00461538
Construction(Type) - EsExterior: yes; Function: Interior; Default Thickness: 6 mm
Data(Type) - Is External: yes
Dimensions(Type) - Area: 4.8 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.5 mm; Peso: 55774.3; Width: 1500 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - CE Mark: yes; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 6mm+ Polished; Model Label: 3200x1500x6mm+ Polished; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Polished; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Polished; Structural Material: Thesize_Neolith_Layla_3200x1500x6mm+ Pulido
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk, Floor:Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk:202334
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1500x6mm+ Silk 6 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Silk; TotalThickness: 6 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1500x6mm+ Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - Model: Layla_low 6mm+ Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Silk; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1500 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; IsExternal: yes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; EsExterior: yes; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1500x6mm+ Silk; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; CEMark: yes; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; IsExtendedWarranty: yes; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.15 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Level: Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 25 m2; Elevation at Bottom: -6 mm; Elevation at Top: 0 mm; Perimeter: 20000 mm; Thickness: 6 mm; Volume: 0.15 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Absorptance: 0.1; Heat Transfer Coefficient (U): 216.667; Roughness: 1; Thermal mass: 120384; Thermal Resistance (R): 0.00461538
Construction(Type) - EsExterior: yes; Default Thickness: 6 mm; Function: Interior
Data(Type) - Is External: yes
Dimensions(Type) - Area: 4.8 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.5 mm; Peso: 55774.3; Width: 1500 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; CE Mark: yes; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 6mm+ Silk; Model Label: 3200x1500x6mm+ Silk; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1500 x 6mm+ - Silk; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Silk; Structural Material: Thesize_Neolith_Layla_3200x1500x6mm+ Silk
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished, Floor:Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished:202358
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1600x12mm Pulido 12 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Polished; TotalThickness: 12 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1600x12mm Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - IsExternal: yes; EsExterior: yes; CEMark: yes; IsExtendedWarranty: yes; Model: Layla_low 12mm Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Polished; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1600 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1600x12mm Polished; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.3 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Related to Mass: no; Room Bounding: yes; Level: Level: Level 1
Dimensions - Elevation at Top: 0 mm; Area: 25 m2; Elevation at Bottom: -12 mm; Perimeter: 20000 mm; Thickness: 12 mm; Volume: 0.3 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Roughness: 1; Absorptance: 0.1; Heat Transfer Coefficient (U): 108.333; Thermal mass: 240768; Thermal Resistance (R): 0.00923077
Construction(Type) - EsExterior: yes; Function: Interior; Default Thickness: 12 mm
Data(Type) - Is External: yes
Dimensions(Type) - Area: 5.12 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.6 mm; Peso: 104987; Width: 1600 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - CE Mark: yes; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 12mm Polished; Model Label: 3200x1600x12mm Polished; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Polished; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Polished; Structural Material: Thesize_Neolith_Layla_3200x1600x12mm Pulido
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk, Floor:Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk:202350
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1600x12mm Silk 12 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Silk; TotalThickness: 12 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1600x12mm Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - IsExternal: yes; EsExterior: yes; CEMark: yes; IsExtendedWarranty: yes; Model: Layla_low 12mm Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Silk; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1600 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1600x12mm Silk; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.3 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Related to Mass: no; Room Bounding: yes; Level: Level: Level 1
Dimensions - Elevation at Top: 0 mm; Area: 25 m2; Elevation at Bottom: -12 mm; Perimeter: 20000 mm; Thickness: 12 mm; Volume: 0.3 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Roughness: 1; Absorptance: 0.1; Heat Transfer Coefficient (U): 108.333; Thermal mass: 240768; Thermal Resistance (R): 0.00923077
Construction(Type) - EsExterior: yes; Function: Interior; Default Thickness: 12 mm
Data(Type) - Is External: yes
Dimensions(Type) - Area: 5.12 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.6 mm; Peso: 104987; Width: 1600 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - CE Mark: yes; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 12mm Silk; Model Label: 3200x1600x12mm Silk; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1600 x 12mm+ - Silk; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Silk; Structural Material: Thesize_Neolith_Layla_3200x1600x12mm Silk
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished, Floor:Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished:202374
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1600x20mm Pulido 20 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Polished; TotalThickness: 20 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1600x20mm Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - IsExternal: yes; EsExterior: yes; CEMark: yes; IsExtendedWarranty: yes; Model: Layla_low 20mm Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Polished; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1600 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1600x20mm Polished; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.5 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Level: Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 25 m2; Elevation at Bottom: -20 mm; Perimeter: 20000 mm; Thickness: 20 mm; Volume: 0.5 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Roughness: 1; Absorptance: 0.1; Heat Transfer Coefficient (U): 65; Thermal mass: 401280; Thermal Resistance (R): 0.0153846
Construction(Type) - EsExterior: yes; Function: Interior; Default Thickness: 20 mm
Data(Type) - Is External: yes
Dimensions(Type) - Area: 5.12 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.6 mm; Peso: 104987; Width: 1600 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - CE Mark: yes; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 20mm Polished; Model Label: 3200x1600x20mm Polished; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Polished; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Polished; Structural Material: Thesize_Neolith_Layla_3200x1600x20mm Pulido
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel

# IfcCovering: Floor:Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk, Floor:Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk:202366
In: Level 1
PredefinedType: FLOORING; Material: Thesize_Neolith_Layla_3200x1600x20mm Silk 20 mm
Pset_CoveringCommon - Reference: A0; FireRating: Si; FlammabilityRating: Clase 0; Finish: Silk; TotalThickness: 20 mm
Pset_ManufacturerTypeInformation - ModelLabel: 3200x1600x20mm Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; ProductionYear: 2020
Neolith EN - IsExternal: yes; EsExterior: yes; CEMark: yes; IsExtendedWarranty: yes; Model: Layla_low 20mm Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk; Manufacturer: Thesize - Neolith Distribution, S.L.; TelephoneContact: +34 964 652 233; ContactEmail: info@neolith.com; Author: Bimetica Parametric Design Services S.L.; ProductURL: www.neolith.com; LicenseNumber: XXX-XXXX4564; Version: RVT_2019; BIMElementIssueDate: 21/10/2020; BIMEelementExpiryDate: 21/10/2021; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; BIM Content Download Platform: https://bimetica.com; Owner: Thesize - Neolith Distribution, S.L.; Finish: Silk; Description: Sintered Stone; URL: https://www.neolith.com/; Width: 1600 mm; Height: 6 mm; Area: 25 m2; IfcExportAs: IfcCovering; IfcExportType: Ceramic Tile Flooring; COBieCategory: IfcCovering; OmniclassCode: 23-15 17 13 13 13; OmniclassTitle: Ceramic Tile Flooring; Masterformat Code: 09 30 13; MasterformatTitle: Ceramic Tiling; Gubimclass Code: 40.20.20.20; Gubimclass Title: Pavements; Uniclass2015 Code: EF_35_10 35 20; Uniclass2015 Title: Pavements; UNSPSC Code: 47131802; UNSPSC Title: Floor finishes or polishes; Level: Level: Level 1; FlammabilityRating: Clase 0; Reference: A0; TrasmitanciaTermica: 1.3; FireRating: Si; TechnicalInformation: https://www.neolith.com/colecciones/; Serie: Classtone; ModelLabel: 3200x1600x20mm Silk; ProductionYear: 2020; SalesRepresentativeContact: info@thesize.es; BimeticaProductProfileURL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; TechnicalSupportContact: neolith@bimsupport.info; BIM Suppport: https://bimsupport.info/es/fabricantes/neolith-bim/; CountryOfSale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; DeclarationOfPerformanceURL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; MeasuringUnit: m2; ContainerProtectionType: Easel; ServiceLifeDuration: Final life of the building; WarrantyPeriod: 10 years; WarrantyContent: Product is guaranteed for 10 years, provided that the maintenance rules are respected; RiskLevel: Green; LEED Credits: 8 possible points; Length: 3200 mm; Volume: 0.5 m3; Bimetica: www.bimetica.com
BaseQuantities - GrossCeilingArea: 25 m2
Constraints - Height Offset From Level: 0 mm; Level: Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 25 m2; Elevation at Bottom: -20 mm; Perimeter: 20000 mm; Thickness: 20 mm; Volume: 0.5 m3
Other - Category: Floors; Family: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk; Family and Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk; Type: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk; Type Id: Floor: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analysis Results(Type) - TrasmitanciaTermica: 1.3
Analytical Properties(Type) - Roughness: 1; Absorptance: 0.1; Heat Transfer Coefficient (U): 65; Thermal mass: 401280; Thermal Resistance (R): 0.0153846
Construction(Type) - EsExterior: yes; Function: Interior; Default Thickness: 20 mm
Data(Type) - Is External: yes
Dimensions(Type) - Area: 5.12 m2; Height: 6 mm; Length: 3200 mm; Perimeter: 9.6 mm; Peso: 104987; Width: 1600 mm
General(Type) - Is Extended Warranty: yes; Point of Contact: info@neolith.com; Service Life Duration: Final life of the building; Warranty Content: Product is guaranteed for 10 years, provided that the maintenance rules are respected; Warranty Period: 10 years
Graphics(Type) - Coarse Scale Fill Color: 16777215
Green Building Properties(Type) - LEED Credits: 8 possible points
Identity Data(Type) - CE Mark: yes; Author: Bimetica Parametric Design Services S.L.; BIM Content Download Platform: https://bimetica.com; BIM Eelement Expiry Date: 21/10/2021; BIM Element Issue Date: 21/10/2020; Bimetica: www.bimetica.com; Bimetica Product Profile URL: https://bimetica.com/es/bim-objects-neolith-sintered-stone-pavement-layla-9147.html; BIMsupport: https://bimsupport.info/es/fabricantes/neolith-bim/; Contact Email: info@neolith.com; Country of Sale: ALBANIA, ALEMANIA, ALGERIE, ANDORRA, ARABIA SAUDITA, ARGENTINA, ARMENIA, AUSTRALIA, AUSTRIA, BAHRAIN, BELGICA, BELIZE, BOSNIA-HERZEGOVINA, BRASIL, BULGARIA, CANADA, CHILE, CHINA, CHIPRE, COLOMBIA, COSTA RICA, CROACIA, CUBA, CURAÇAO / NETHERLANDS ANTILLES, DINAMARCA, EGYPTO, ESLOVAQUIA, ESLOVENIA, ESTADOS UNIDOS, ESTONIA, FINLANDIA, FRANCIA, GEORGIA, GRECIA, GUADALUPE, GUATEMALA, HOLANDA, HONG KONG, HUNGRIA, INDIA, INDONESIA, IRAN, IRLANDA, ISLANDIA, ISRAEL, ITALIA, JAMAICA, JAPON, JORDANIA, KAZAKHSTAN, KENIA, KOREA, KOSOVO, KUWAIT, LETONIA, LIBANO, LIBIA, LITHUANIA, MACEDONIA, MALAYSIA, MALTA, MARRUECOS, MEXICO, NICARAGUA, NORUEGA, NUEVA ZELANDA, PANAMA, PERU, POLONIA, PORTUGAL, PUERTO RICO, QUATAR, REINO UNIDO, REPUBLICA CHECA, REPUBLICA DE SAN MARINOÃ‚Â , REPUBLICA DOMINICANA, RUMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPUR, SOUTH AFRICA, SRI LANKA, SUECIA, SUIZA, SULTANATE OF OMAN, TAILANDIA, TAIWAN, TUNEZ, TURQUIA, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Declaration of Performance URL: https://www.neolith.com/zona-de-descargas/#fichas-tecnicas; Description: Sintered Stone; FireRating: Si; FlammabilityRating: Clase 0; GDO-BIM Standard Version: GDO-BIM V02; History: (RVT2019) Element Creation.; License Number: XXX-XXXX4564; Manufacturer: Thesize - Neolith Distribution, S.L.; Measuring Unit: m2; Model: Layla_low 20mm Silk; Model Label: 3200x1600x20mm Silk; Owner: Thesize - Neolith Distribution, S.L.; Production Year: 2020; Product URL: www.neolith.com; Reference: A0; Sales Representative Contact: info@thesize.es; Series: Classtone; Technical Information: https://www.neolith.com/colecciones/; Technical Support Contact: neolith@bimsupport.info; Telephone Contact: +34 964 652 233; Type Name: Thesize_Neolith_Layla_3200 x 1600 x 20mm+ - Silk; URL: https://www.neolith.com/; Version: RVT_2019
Materials and Finishes(Type) - Finish: Silk; Structural Material: Thesize_Neolith_Layla_3200x1600x20mm Silk
Other(Type) - Category: Floors; Family Name: Floor; Risk Level: Green
Phasing(Type) - Container Protection Type: Easel
